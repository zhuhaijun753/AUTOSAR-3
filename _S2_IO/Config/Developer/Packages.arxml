<?xml version="1.0" encoding="utf-8"?>
<!-- edited with XMLSpy v2009 sp1 (http://www.altova.com) by Vector Employee (Vector Informatik GmbH) -->
<!--
This file was saved with a tool from Vector Informatik GmbH
-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-2-1.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
	<AR-PACKAGES>
		<AR-PACKAGE UUID="68A34FC5-AC4E-4E41-BB3C-993E4F72BF5E">
			<SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE UUID="9E1AB99B-F1CD-4222-9301-B74F78E31EEC">
					<SHORT-NAME>BaseTypes</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="5502C6CE-12DE-4BE5-A551-170A5CCDC5C6">
					<SHORT-NAME>CompuMethods</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="C68A2F40-E37F-41C4-AA92-B00E5593EFEC">
					<SHORT-NAME>DataConstrs</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="2B5634A8-068E-4B41-8619-9F9C97FD4E17">
					<SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="7AEBE6C5-536F-412D-8355-D28569FB8A97">
			<SHORT-NAME>Blueprints</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE UUID="2B25C942-C392-4A56-AF41-CEFCD4E33073">
					<SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="C679F333-5FB4-4C65-A139-F33C762BDC2C">
					<SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="06AFBEC0-32F3-4209-8701-D957AD48A0A5">
			<SHORT-NAME>CanFrame</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="B279CF1C-2C8E-4040-B4C9-5683B747B332">
			<SHORT-NAME>Cluster</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="189D2A21-CD04-4527-B6F4-5106C9ECD183">
			<SHORT-NAME>ComponentTypes</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE UUID="BA250A3A-7F04-44E8-AFC4-BAE4323423C9">
					<SHORT-NAME>ConstantMappingSets</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="FED3B4EF-35E3-4C03-A37C-1B744D99AEF8">
					<SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="0E4A72FD-16FB-4A2C-BF1D-93EABC4327E8">
			<SHORT-NAME>Constant</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="AB5B9E86-73F3-4C0C-BF7A-67210145844B">
			<SHORT-NAME>Constants</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="72110331-A23B-4E0D-BD7E-1F50E438D908">
			<SHORT-NAME>DataType</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE UUID="7EE90078-CC15-47BB-BCD5-DD7A6D610FDC">
					<SHORT-NAME>Semantics</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="D3814C29-AF58-4402-AB6F-29C334F44920">
			<SHORT-NAME>DataTypes</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE UUID="1952047B-2E69-4487-9B0F-C956E0C10654">
					<SHORT-NAME>BaseTypes</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="F2DC03BE-0BE2-4B41-A60E-6E1F261D62B9">
					<SHORT-NAME>CompuMethods</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="59301BC3-D4B3-4C06-896C-1102FE630147">
					<SHORT-NAME>DataConstrs</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="FE905240-F231-4EBE-BA81-9451F4CCAC5C">
					<SHORT-NAME>PlatformTypes</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="54861CA7-0848-445A-AD5A-CCCCC7519B5A">
					<SHORT-NAME>Units</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="9F428037-0170-430A-BE16-03CCBE7CA82C">
			<SHORT-NAME>Diagnostics</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="1461EDB2-C95F-4AA0-A6B9-AE9923B593BE">
			<SHORT-NAME>ECU</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="648BD30F-5174-470F-AA7B-6491D085DD16">
			<SHORT-NAME>ECUCompositions</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="A1F73A9A-85B0-44B5-BE99-0CD6EED8B8C0">
			<SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="F2E752AB-D8DC-4C92-A312-D0F10EBE7C6B">
			<SHORT-NAME>EndToEndProtections</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="20F2233D-968C-4763-95A1-40CB2E06E581">
			<SHORT-NAME>FlexrayFrame</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="3D3FCCA1-0C08-46CC-8128-70E4A41B6EE3">
			<SHORT-NAME>Gateway</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="C57901E8-0384-4E86-AF73-97F5B0C58BC5">
			<SHORT-NAME>IPDUGroup</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="88CBC190-C3BB-4B2D-86AE-1F6CD69E170B">
			<SHORT-NAME>ISignal</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="C0869BB9-7973-43F2-8A92-346E4135D79B">
			<SHORT-NAME>LinFrame</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="f3031cc8-f367-42cb-b2b2-331e67ef4724">
			<SHORT-NAME>MICROSAR</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE UUID="d0d98b09-6f93-4062-8517-b0779266cc69">
					<SHORT-NAME>BswM_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="a144c7bd-b4a1-4509-9c11-e054918ec2a2">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="86705898-0a91-4265-a6dd-dbc0a4ca3f2c">
							<SHORT-NAME>DataTypes</SHORT-NAME>
							<AR-PACKAGES>
								<AR-PACKAGE UUID="3e9d2220-793b-44bc-bd61-aee4caa57a25">
									<SHORT-NAME>CompuMethods</SHORT-NAME>
								</AR-PACKAGE>
							</AR-PACKAGES>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="36f52bee-6d22-4659-9f45-d49dbe9bd174">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="e9c8a725-2aa3-4f75-8662-9ef7c9b26fd2">
					<SHORT-NAME>ComM_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="0f8672e8-9c78-4796-aa29-ab202ee44bfb">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="25ffd487-0337-4caa-9297-b05c1a8956d8">
							<SHORT-NAME>DataTypes</SHORT-NAME>
							<AR-PACKAGES>
								<AR-PACKAGE UUID="17a76617-24ae-468f-9b2f-f9160beb62b6">
									<SHORT-NAME>CompuMethods</SHORT-NAME>
								</AR-PACKAGE>
								<AR-PACKAGE UUID="ebf79460-29f3-41a2-bf15-3dc1ac9685d2">
									<SHORT-NAME>DataConstrs</SHORT-NAME>
								</AR-PACKAGE>
							</AR-PACKAGES>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="8b19c0cf-da73-4299-b3ac-bf83068d0268">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="cdade5f2-62bf-45e1-b7a7-ffac4f515c5f">
					<SHORT-NAME>Dcm_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="90d2198f-14d7-4f25-95ca-c0fd992fe47b">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="1b04c390-4e19-45e2-af52-6b25583fb48e">
							<SHORT-NAME>DataTypes</SHORT-NAME>
							<AR-PACKAGES>
								<AR-PACKAGE UUID="aa49568d-a2b0-4577-b1d2-ae511fc1f8dc">
									<SHORT-NAME>CompuMethods</SHORT-NAME>
								</AR-PACKAGE>
								<AR-PACKAGE UUID="4d0fd600-547f-49be-8268-5868af4aec3b">
									<SHORT-NAME>DataConstrs</SHORT-NAME>
								</AR-PACKAGE>
							</AR-PACKAGES>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="2dfe0b0c-534d-42f5-9cff-6c9c42734415">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="c18c68a9-7446-41ef-9941-df853a5777fc">
					<SHORT-NAME>Dem_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="de9ad43c-8b46-4c61-b401-d3671e5a61d9">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="f2a47595-452f-482d-ab76-7709cc307291">
							<SHORT-NAME>DataTypes</SHORT-NAME>
							<AR-PACKAGES>
								<AR-PACKAGE UUID="7ee7601a-6f45-45b9-a4fc-674d6679069c">
									<SHORT-NAME>CompuMethods</SHORT-NAME>
								</AR-PACKAGE>
								<AR-PACKAGE UUID="9ccc5fa5-fd9a-4651-a8ce-12f6f1b6610a">
									<SHORT-NAME>DataConstrs</SHORT-NAME>
								</AR-PACKAGE>
							</AR-PACKAGES>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="b9e1267b-df5d-474c-baf8-1c059d193961">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="c4787ddf-3004-443d-b5b7-6d1f1da152e4">
					<SHORT-NAME>Det_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="a5d66168-a489-46e2-9853-915d834cb21d">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="71ba033a-cb00-463f-a3e2-7fd7e02afa08">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="eb89c2e0-db0e-4952-94c8-8f91a16d462f">
					<SHORT-NAME>EcuM_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="5d5ca60e-af90-4b4d-b010-982ef6979a4b">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="ac696f66-af53-4aa2-b19e-f76d709ec50f">
							<SHORT-NAME>DataTypes</SHORT-NAME>
							<AR-PACKAGES>
								<AR-PACKAGE UUID="bf709aa9-7268-4e80-b863-4a5d2425384b">
									<SHORT-NAME>CompuMethods</SHORT-NAME>
								</AR-PACKAGE>
								<AR-PACKAGE UUID="6f4a6fb2-6ba9-4715-84d9-e100ac9231f4">
									<SHORT-NAME>DataConstrs</SHORT-NAME>
								</AR-PACKAGE>
							</AR-PACKAGES>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="e1447c29-0cba-42ac-bea9-6ed642bb0e8c">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="890511e4-45df-441b-bc2f-971438d9ec45">
					<SHORT-NAME>IoHwAb_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="7afaafe0-184d-4504-9813-748b30daa91d">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="9b4fd93e-1ac1-4011-918a-8d8705319caa">
							<SHORT-NAME>DataTypes</SHORT-NAME>
							<AR-PACKAGES>
								<AR-PACKAGE UUID="8011651c-3a80-4ea8-a418-41028c290d97">
									<SHORT-NAME>DataConstrs</SHORT-NAME>
								</AR-PACKAGE>
							</AR-PACKAGES>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="d4460f36-e77e-4c51-b034-540eb16dde3e">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="a0b8b870-44b0-4439-a412-663f4fda6a0a">
					<SHORT-NAME>NvM_swc</SHORT-NAME>
					<AR-PACKAGES>
						<AR-PACKAGE UUID="88443bb6-09ae-404e-825a-210eb91367d5">
							<SHORT-NAME>ComponentTypes</SHORT-NAME>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="277cbbab-f6fb-42ae-bafb-1518ec247e29">
							<SHORT-NAME>DataTypes</SHORT-NAME>
							<AR-PACKAGES>
								<AR-PACKAGE UUID="5b46efb9-ef0f-4a56-926b-5a50e9719e57">
									<SHORT-NAME>CompuMethods</SHORT-NAME>
								</AR-PACKAGE>
								<AR-PACKAGE UUID="b87328f6-c782-49c1-a4b2-d8449816b8e7">
									<SHORT-NAME>DataConstrs</SHORT-NAME>
								</AR-PACKAGE>
							</AR-PACKAGES>
						</AR-PACKAGE>
						<AR-PACKAGE UUID="53075bba-0e48-4a58-aeed-62a4bf53a9c2">
							<SHORT-NAME>Interfaces</SHORT-NAME>
						</AR-PACKAGE>
					</AR-PACKAGES>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="14D1EC96-F277-4F71-ADC8-2D3C6FDDBEC8">
			<SHORT-NAME>ModeDclrGroups</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="10791721-09F0-4BD3-BAC7-6CD37C91FADD">
			<SHORT-NAME>NM</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="440EC28A-F6B9-40E1-BCF8-A29DC6D83B06">
			<SHORT-NAME>PDU</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="370D9FA1-1FF5-4986-8234-EB01CA02454C">
			<SHORT-NAME>PortInterfaces</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="21434688-D132-4F65-8AC3-1D1A03D56F34">
			<SHORT-NAME>Predefined_DEV</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE UUID="F115E547-CB00-4F82-9327-4237809BCA2B">
					<SHORT-NAME>CompuMethods</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="73E99B63-798E-494F-9BE9-E7D89A957601">
					<SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE UUID="F6D3462E-1043-4302-A289-B24247A5919D">
					<SHORT-NAME>PortInterfaces</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="8778BBC7-EEAE-4CED-A697-0844E917EE3D">
			<SHORT-NAME>Signal</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="4F4C764A-43C7-4ED8-8788-B0C3A42A7C8C">
			<SHORT-NAME>Systems</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="B713CBCD-C919-4548-9101-1DC08EF2E97E">
			<SHORT-NAME>TP</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE UUID="7B4780FF-D3B1-4429-A1DB-E132ADADB8D3">
			<SHORT-NAME>VehicleProject</SHORT-NAME>
		</AR-PACKAGE>
	</AR-PACKAGES>
</AUTOSAR>
